# Keil uVision project AGV_V1.01.uvprojx, settings and files
target AGV_V (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AGV_V1.01 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,ARM_MATH_CM4,__CC_ARM
  c include: ..\Library\FwLib\inc;..\Library\FatFS\inc;..\Library\CMSIS\CM4\DeviceSupport\ST\STM32F40x;..\FreeRTOS\portable\GCC\ARM_CM4F;..\FreeRTOS\include;..\Users\xzz_users\App\inc;..\Users\xzz_users\config\inc;..\Users\McuPeripheralDrivers\inc;..\Users\Global\inc;..\Users\Control\inc;..\Users\HardwarePeripheralDrivers\inc;..\Users\App\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ../Users/xzz_users/App/src/: app.c
  group Mcu Peripheral Drivers
    ../Users/xzz_users/config/src/: stm32f4xx_usart_config.c delay.c agv_handle.c stm32f4xx_it.c agv_deal.c
    ../Users/Control/src/: BCBCtrlIMU.c
    ../Users/HardwarePeripheralDrivers/src/: BCBMpu6050Driver.c
    ../Users/McuPeripheralDrivers/src/: stm32f4xx_iic_config.c
  group FwLib
    ../Library/FwLib/src/: system_stm32f4xx.c
    ../Library/FwLib/lib/: STM32f4xx.lib
    ../Library/FwLib/inc/: system_stm32f4xx.h
  group StartUp
    ../Library/CMSIS/CM4/DeviceSupport/ST/STM32F40x/: startup_stm32f4xx.s
software components: CMSIS:CORE 4.1.0
